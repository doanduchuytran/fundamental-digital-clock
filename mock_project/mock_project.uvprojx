# Keil uVision project mock_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mock_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: C:\Users\Huy\AppData\Local\Arm\Packs\Keil\S32_SDK_DFP\1.5.0\platform\devices\S32K144\linker\armc\S32K144_64_flash.sct
  group Source Group 1
    ./: main.c main.h software_timer.c software_timer.h button.h button.c bit_manipulate.h bit_manipulate.c global.h global.c port.h port.c led.h led.c uart.h uart.c main_system.h main_system.c spi.h spi.c clock.h clock.c max7219.h max7219.c gpio.h gpio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
